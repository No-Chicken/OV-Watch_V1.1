# Keil uVision project test1.uvprojx, settings and files
target test1 (5060960::V5.06 update 7 for Certification (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: test1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\SYSTEM;..\HARDWARE\SPL06_001;..\HARDWARE\MPU6050;..\HARDWARE\LSM303DLH;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\EM7028;..\MiddleWares\FreeRTOS\portable\RVDS\ARM_CM4F;..\MiddleWares\FreeRTOS\CMSIS_RTOS_V2;..\MiddleWares\FreeRTOS\include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;..\GUI\lvgl;..\GUI;..\GUI_APP;..\GUI\porting;..\GUI\lvgl\src;..\HARDWARE\KEY;..\HARDWARE\POWER;..\API_LIB\DMP
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User
    ../Src/: main.c gpio.c adc.c rtc.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group SYS
    ../SYSTEM/: delay.c
  group HARDWARE
    ../HARDWARE/SPL06_001/: SPL06_001.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/LSM303DLH/: LSM303.c
    ../HARDWARE/LCD/: lcd.c lcd_init.c
    ../HARDWARE/IIC/: i2c_hal.c
    ../HARDWARE/EM7028/: em70x8.c HrAlgorythm.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/POWER/: power.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group USER_TASK
    ../USER_TASK/: freertos.c
  group GUI
    ../GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../GUI/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../GUI/lvgl/src/extra/: lv_extra.c
    ../GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
  group GUI_PORT
    ../GUI/porting/: lv_port_disp.c
  group GUI_APP
    ../GUI_APP/: HeartBeatFont.c ui.c ui_helpers.c ui_img_background1_png.c ui_img_ow3_png.c EnvFont_45.c compass_needle.c
  group DMP
    ../API_LIB/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c user_func.c
software components: CMSIS:CORE 4.3.0
